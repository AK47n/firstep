# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\user;..\ml_libs;..\code;..\sys
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./: main.c isr.c
  group code
    ../code/: motor.c motor.h pid.c pid.h gray_track.c gray_track.h filter.c filter.h digit_uart.c digit_uart.h ball_detect.c ball_detect.h
  group sys
    ../sys/: system_stm32f10x.h system_stm32f10x.c stm32f10x.h startup_stm32f10x_md.s core_cmInstr.h core_cmFunc.h core_cm3.h
  group ml_libs
    ../ml_libs/: headfile.h ml_mpu6050.c ml_mpu6050.h ml_i2c.c ml_i2c.h ml_oled.c ml_oled.h ml_hmc5883l.c ml_hmc5883l.h
    ../ML_LIBS/: ml_gpio.c ml_gpio.h ml_delay.c ml_delay.h ml_nvic.c ml_nvic.h ml_pwm.c ml_pwm.h ml_tim.c ml_tim.h ml_uart.c ml_uart.h ml_oled_font.h ml_adc.c ml_adc.h ml_exti.c ml_exti.h
