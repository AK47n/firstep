# Keil uVision project KeyFob.uvprojx, settings and files
target KeyFob (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: KeyFob +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\key_fob;..\ml_libs;..\sys
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group key_fob
    ./: main.c isr.c zigbee_uart.c headfile.h config.h zigbee_uart.h
  group ml_libs
    ../ml_libs/: ml_gpio.c ml_tim.c ml_uart.c ml_nvic.c ml_delay.c headfile.h ml_gpio.h ml_tim.h ml_uart.h ml_nvic.h ml_delay.h ml_oled.h
  group sys
    ../sys/: system_stm32f10x.h system_stm32f10x.c stm32f10x.h startup_stm32f10x_md.s core_cmInstr.h core_cmFunc.h core_cm3.h
