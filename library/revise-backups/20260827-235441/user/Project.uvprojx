# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\ml_libs;..\sys;..;.\..\modules\beep\code;.\..\modules\key\code;.\..\modules\motor\code;.\..\modules\ntb_time\code
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group key
    ../key/: startup_stm32f10x_md.s
  group ml_libs
    ../ml_libs/: ml_adc.c ml_delay.c ml_exti.c ml_gpio.c ml_i2c.c ml_led.c ml_nvic.c ml_oled.c ml_pwm.c ml_systick.c ml_tim.c ml_uart.c
  group sys
    ../sys/: system_stm32f10x.c
  group user
    ../: isr.c main.c
  group modules
    ./../modules/beep/code/: beep_stm32.c
    ./../modules/key/code/: key_stm32.c
    ./../modules/motor/code/: motor_stm32.c
    ./../modules/ntb_time/code/: ntb_time_stm32.c
